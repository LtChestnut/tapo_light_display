## tools/secondary_sleep/sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_UNICORE=y
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
CONFIG_BT_ENABLED=n
CONFIG_LOG_DEFAULT_LEVEL_INFO=y
```
